## hil/firmware/PX4-Autopilot/src/examples/psonn/Kconfig
```kconfig
menuconfig EXAMPLES_PSONN
	bool "psonn study controller (simulation only)"
	default n
```
